# IAR project littevgl.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 51
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6G3CVM05; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL; FSL_RTOS_FREE_RTOS; EVK_MCIMX6UL; CYCLONE_OS_DEBUG; GPL_LICENSE_TERMS_ACCEPTED
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\rtos\freertos_9.0.0\Source\portable\IAR\ARM_CA9; ..\..\..\rtos\freertos_9.0.0\Source\include; ..\..\..\CORTEXA\Include; ..\..\..\devices; ..; ..\..\..; ..\..\..\rtos\freertos_9.0.0/Source; ..\..\..\devices\MCIMX6G3; ..\..\..\platform\utilities\debug_console; ..\..\..\devices\MCIMX6G3\utilities; ..\..\..\devices\MCIMX6G3\drivers; ..\..\..\middleware\littlevgl\lv_drivers; ..\..\..\middleware\littlevgl\lv_drivers\display; ..\..\..\middleware\littlevgl\lv_drivers\indev; ..\..\..\middleware\littlevgl\lvgl; ..\..\..\middleware\littlevgl\lvgl\lv_draw; ..\..\..\middleware\littlevgl\lvgl\lv_hal; ..\..\..\middleware\littlevgl\lvgl\lv_misc; ..\..\..\middleware\littlevgl\lvgl\lv_misc\lv_fonts; ..\..\..\middleware\littlevgl\lvgl\lv_objx; ..\..\..\middleware\littlevgl\lvgl\lv_themes; ..\..\..\middleware\littlevgl; ..\..\..\middleware\littlevgl\lv_examples; ..\..\..\middleware\littlevgl\lv_examples\lv_apps\demo; ..\..\..\middleware\CycloneTCP\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../..
  OBJCOPY.OOCOutputFile: littevgl.bin
  ILINK.IlinkOutputFile: littevgl.out
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_ram.icf
  ILINK.IlinkAdditionalLibs: ..\..\discovery_core\lib\ddr_debug\discovery_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\discovery_core\lib\debug\discovery_core.a
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_ram.icf
  ILINK.IlinkAdditionalLibs: ..\..\discovery_core\lib\ddr_release\discovery_core.a
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\discovery_core\lib\release\discovery_core.a
  group board
    ../: board.c board.h clock_config.c clock_config.h clock_config_ocram.c pin_mux.c pin_mux.h
  group common
    ../../../middleware/CycloneTCP/common/: debug.c debug.h os_port_freertos.c os_port_freertos.h
  group doc
    ../: readme.txt
  group drivers
    ../../../devices/MCIMX6G3/drivers/: fsl_adc_5hc.c fsl_adc_5hc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_elcdif.c fsl_elcdif.h fsl_epit.c fsl_epit.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_tsc.c fsl_tsc.h fsl_uart.c fsl_uart.h
  group drivers/freertos
    ../../../devices/MCIMX6G3/drivers/: fsl_uart_freertos.c fsl_uart_freertos.h
  group freertos
    ../../../rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../rtos/freertos_9.0.0/Source/portable/low_power_tickless/: fsl_tickless_epit.c
    ../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9/: port.c portASM.h portASM.s portmacro.h
  group littlevgl
    ../../../middleware/littlevgl/: lv_conf.h lv_ex_conf.h
  group littlevgl/lv_drivers/display
    ../../../middleware/littlevgl/lv_drivers/display/: imx6x_elcdif.h
  group littlevgl/lv_drivers/indev
    ../../../middleware/littlevgl/lv_drivers/indev/: imx6x_adc_touch.h
  group littlevgl/lv_examples/lv_apps/benchmark
    ../../../middleware/littlevgl/lv_examples/lv_apps/benchmark/: benchmark.c benchmark.h benchmark_bg.c
  group littlevgl/lv_examples/lv_apps/demo
    ../../../middleware/littlevgl/lv_examples/lv_apps/demo/: demo.c demo.h img_bubble_pattern.c
  group littlevgl/lv_examples/lv_apps/sysmon
    ../../../middleware/littlevgl/lv_examples/lv_apps/sysmon/: sysmon.c sysmon.h
  group littlevgl/lv_examples/lv_apps/terminal
    ../../../middleware/littlevgl/lv_examples/lv_apps/terminal/: terminal.c terminal.h
  group littlevgl/lv_examples/lv_apps/tpcal
    ../../../middleware/littlevgl/lv_examples/lv_apps/tpcal/: tpcal.c tpcal.h
  group littlevgl/lv_examples/lv_tests/lv_test_misc
    ../../../middleware/littlevgl/lv_examples/lv_tests/lv_test_misc/: lv_test_task.c lv_test_task.h
  group littlevgl/lv_examples/lv_tests/lv_test_obj
    ../../../middleware/littlevgl/lv_examples/lv_tests/lv_test_obj/: lv_test_obj.c lv_test_obj.h
  group littlevgl/lv_examples/lv_tests/lv_test_objx/lv_test_list
    ../../../middleware/littlevgl/lv_examples/lv_tests/lv_test_objx/lv_test_list/: lv_test_list.c lv_test_list.h
  group littlevgl/lv_examples/lv_tests/lv_test_theme
    ../../../middleware/littlevgl/lv_examples/lv_tests/lv_test_theme/: lv_test_theme.c lv_test_theme.h
  group littlevgl/lvgl/lv_core
    ../../../middleware/littlevgl/lvgl/lv_core/: lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_refr.c lv_refr.h lv_style.c lv_style.h lv_vdb.c lv_vdb.h
  group littlevgl/lvgl/lv_draw
    ../../../middleware/littlevgl/lvgl/lv_draw/: lv_draw.c lv_draw.h lv_draw_rbasic.c lv_draw_rbasic.h lv_draw_vbasic.c lv_draw_vbasic.h
  group littlevgl/lvgl/lv_hal
    ../../../middleware/littlevgl/lvgl/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group littlevgl/lvgl/lv_misc
    ../../../middleware/littlevgl/lvgl/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_circ.c lv_circ.h lv_color.c lv_color.h lv_font.c lv_font.h lv_fs.c lv_fs.h lv_ll.c lv_ll.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_trigo.c lv_trigo.h lv_txt.c lv_txt.h lv_ufs.c lv_ufs.h
  group littlevgl/lvgl/lv_misc/lv_fonts
    ../../../middleware/littlevgl/lvgl/lv_misc/lv_fonts/: lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c lv_symbol_def.h
  group littlevgl/lvgl/lv_objx
    ../../../middleware/littlevgl/lvgl/lv_objx/: lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnm.c lv_btnm.h lv_cb.c lv_cb.h lv_chart.c lv_chart.h lv_cont.c lv_cont.h lv_ddlist.c lv_ddlist.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_kb.c lv_kb.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_list.c lv_list.h lv_lmeter.c lv_lmeter.h lv_mbox.c lv_mbox.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_sw.c lv_sw.h lv_ta.c lv_ta.h lv_tabview.c lv_tabview.h lv_win.c lv_win.h
  group littlevgl/lvgl/lv_themes
    ../../../middleware/littlevgl/lvgl/lv_themes/: lv_theme.c lv_theme.h lv_theme_alien.c lv_theme_alien.h lv_theme_default.c lv_theme_default.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_night.c lv_theme_night.h lv_theme_templ.c lv_theme_templ.h lv_theme_zen.c lv_theme_zen.h
  group source
    ../: FreeRTOSConfig.h main.c ts_calibrate.c ts_calibrate.h
  group startup
    ../../../devices/MCIMX6G3/: MCIMX6G3.h system_MCIMX6G3.c system_MCIMX6G3.h
    ../../../devices/MCIMX6G3/iar/: startup_MCIMX6G3.s
