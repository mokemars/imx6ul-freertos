# IAR project cyclonetcp_enet.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 51
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6G3CVM05; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL; FSL_RTOS_FREE_RTOS; EVK_MCIMX6UL; CYCLONE_OS_DEBUG; GPL_LICENSE_TERMS_ACCEPTED
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\/rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9; ..\..\..\/rtos/freertos_9.0.0/Source/include; ..\..\..\/CORTEXA/Include; ..\..\..\/devices; ..; ..\..\..; ..\..\..\/rtos/freertos_9.0.0/Source; ..\..\..\devices\MCIMX6G3\drivers; ..\..\..\/platform/utilities/debug_console; ..\..\..\/platform/utilities/debug_console/io; ..\..\..\/platform/utilities/debug_console/str; ..\..\..\/devices/MCIMX6G3/utilities; ..\..\..\/devices/MCIMX6G3; ..\..\..\middleware\CycloneTCP\cyclone_crypto; ..\..\..\middleware\CycloneTCP\cyclone_ssl; ..\..\..\middleware\CycloneTCP\cyclone_tcp; ..\..\..\middleware\CycloneTCP\common; ..\..\..\middleware\fatfs_0.12c\src; ..\..\..\middleware\fatfs_0.12c\src\fsl_sd_disk; ..\..\..\middleware\sdmmc_2.1.2\inc; ..\..\..\middleware\sdmmc_2.1.2\port
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: cyclonetcp_enet.bin
  prebuild: ..\..\..\middleware\CycloneTCP\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\res.c
  ILINK.IlinkOutputFile: cyclonetcp_enet.out
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_ram.icf
  ILINK.IlinkAdditionalLibs: ..\..\discovery_core\lib\ddr_debug\discovery_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\discovery_core\lib\debug\discovery_core.a
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_ram.icf
  ILINK.IlinkAdditionalLibs: ..\..\discovery_core\lib\ddr_release\discovery_core.a
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\discovery_core\lib\release\discovery_core.a
  group board
    ../: board.c board.h clock_config.c clock_config.h clock_config_ocram.c pin_mux.c pin_mux.h
  group cyclonetcp/common
    ../../../middleware/CycloneTCP/common/: compiler_port.h cpu_endian.c cpu_endian.h date_time.c date_time.h debug.h error.h fs_port.h fs_port_fatfs.c os_port.h os_port_freertos.c os_port_freertos.h path.c path.h resource_manager.c str.c str.h
    ../: debug.c
  group cyclonetcp/cyclone_crypto/aead
    ../../../middleware/CycloneTCP/cyclone_crypto/aead/: ccm.c ccm.h chacha20_poly1305.c chacha20_poly1305.h gcm.c gcm.h
  group cyclonetcp/cyclone_crypto/certificate
    ../../../middleware/CycloneTCP/cyclone_crypto/certificate/: pem_import.c pem_import.h x509_cert_parse.c x509_cert_parse.h x509_cert_validate.c x509_cert_validate.h x509_common.c x509_common.h
  group cyclonetcp/cyclone_crypto/cipher
    ../../../middleware/CycloneTCP/cyclone_crypto/cipher/: aes.c aes.h aria.c aria.h camellia.c camellia.h chacha.c chacha.h des.c des.h des3.c des3.h idea.c idea.h present.c present.h rc4.c rc4.h rc6.c rc6.h seed.c seed.h
  group cyclonetcp/cyclone_crypto/cipher_mode
    ../../../middleware/CycloneTCP/cyclone_crypto/cipher_mode/: cbc.c cbc.h cfb.c cfb.h ctr.c ctr.h ecb.c ecb.h ofb.c ofb.h xts.c xts.h
  group cyclonetcp/cyclone_crypto/core
    ../../../middleware/CycloneTCP/cyclone_crypto/core/: crypto.h
  group cyclonetcp/cyclone_crypto/ecc
    ../../../middleware/CycloneTCP/cyclone_crypto/ecc/: ec.c ec.h ec_curves.c ec_curves.h ecdh.c ecdh.h ecdsa.c ecdsa.h
  group cyclonetcp/cyclone_crypto/encoding
    ../../../middleware/CycloneTCP/cyclone_crypto/encoding/: asn1.c asn1.h base64.c base64.h oid.c oid.h
  group cyclonetcp/cyclone_crypto/hash
    ../../../middleware/CycloneTCP/cyclone_crypto/hash/: blake2b.c blake2b.h blake2b160.c blake2b160.h blake2b256.c blake2b256.h blake2b384.c blake2b384.h blake2b512.c blake2b512.h blake2s.c blake2s.h blake2s128.c blake2s128.h blake2s160.c blake2s160.h blake2s224.c blake2s224.h blake2s256.c blake2s256.h md2.c md2.h md4.c md4.h md5.c md5.h ripemd128.c ripemd128.h ripemd160.c ripemd160.h sha1.c sha1.h sha224.c sha224.h sha256.c sha256.h sha384.c sha384.h sha3_224.c sha3_224.h sha3_256.c sha3_256.h sha3_384.c sha3_384.h sha3_512.c sha3_512.h sha512.c sha512.h sha512_224.c sha512_224.h sha512_256.c sha512_256.h tiger.c tiger.h whirlpool.c whirlpool.h
  group cyclonetcp/cyclone_crypto/kdf
    ../../../middleware/CycloneTCP/cyclone_crypto/kdf/: pkcs5.c pkcs5.h
  group cyclonetcp/cyclone_crypto/mac
    ../../../middleware/CycloneTCP/cyclone_crypto/mac/: cmac.c cmac.h gmac.c gmac.h hmac.c hmac.h poly1305.c poly1305.h
  group cyclonetcp/cyclone_crypto/mpi
    ../../../middleware/CycloneTCP/cyclone_crypto/mpi/: mpi.c mpi.h mpi_arm_v7m_iar.s
  group cyclonetcp/cyclone_crypto/pkc
    ../../../middleware/CycloneTCP/cyclone_crypto/pkc/: dh.c dh.h dsa.c dsa.h rsa.c rsa.h
  group cyclonetcp/cyclone_crypto/rng
    ../../../middleware/CycloneTCP/cyclone_crypto/rng/: yarrow.c yarrow.h
  group cyclonetcp/cyclone_crypto/xof
    ../../../middleware/CycloneTCP/cyclone_crypto/xof/: keccak.c keccak.h shake128.c shake128.h shake256.c shake256.h
  group cyclonetcp/cyclone_ssl
    ../../../middleware/CycloneTCP/cyclone_ssl/: dtls_misc.c dtls_misc.h dtls_record.c dtls_record.h ssl_misc.c ssl_misc.h tls.c tls.h tls_cache.c tls_cache.h tls_certificate.c tls_certificate.h tls_cipher_suites.c tls_cipher_suites.h tls_client.c tls_client.h tls_client_misc.c tls_client_misc.h tls_common.c tls_common.h tls_handshake.c tls_handshake.h tls_handshake_hash.c tls_handshake_hash.h tls_handshake_misc.c tls_handshake_misc.h tls_key_material.c tls_key_material.h tls_legacy.h tls_misc.c tls_misc.h tls_record.c tls_record.h tls_server.c tls_server.h tls_server_misc.c tls_server_misc.h tls_signature.c tls_signature.h
  group cyclonetcp/cyclone_tcp/core
    ../../../middleware/CycloneTCP/cyclone_tcp/core/: bsd_socket.c bsd_socket.h ethernet.c ethernet.h ip.c ip.h net.c net.h net_legacy.h net_mem.c net_mem.h nic.c nic.h ping.c ping.h raw_socket.c raw_socket.h socket.c socket.h tcp.c tcp.h tcp_fsm.c tcp_fsm.h tcp_misc.c tcp_misc.h tcp_timer.c tcp_timer.h udp.c udp.h
  group cyclonetcp/cyclone_tcp/dhcp
    ../../../middleware/CycloneTCP/cyclone_tcp/dhcp/: dhcp_client.c dhcp_client.h dhcp_common.c dhcp_common.h dhcp_debug.c dhcp_debug.h dhcp_server.c dhcp_server.h
  group cyclonetcp/cyclone_tcp/dhcpv6
    ../../../middleware/CycloneTCP/cyclone_tcp/dhcpv6/: dhcpv6_client.c dhcpv6_client.h dhcpv6_common.c dhcpv6_common.h dhcpv6_debug.c dhcpv6_debug.h dhcpv6_relay.c dhcpv6_relay.h
  group cyclonetcp/cyclone_tcp/dns
    ../../../middleware/CycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_cache.h dns_client.c dns_client.h dns_common.c dns_common.h dns_debug.c dns_debug.h
  group cyclonetcp/cyclone_tcp/dns_sd
    ../../../middleware/CycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c dns_sd.h
  group cyclonetcp/cyclone_tcp/drivers/phy
    ../../../middleware/CycloneTCP/cyclone_tcp/drivers/phy/: lan8720_driver.c lan8720_driver.h
  group cyclonetcp/cyclone_tcp/ftp
    ../../../middleware/CycloneTCP/cyclone_tcp/ftp/: ftp_client.c ftp_client.h ftp_server.c ftp_server.h ftp_server_commands.c ftp_server_commands.h ftp_server_events.c ftp_server_events.h ftp_server_misc.c ftp_server_misc.h
  group cyclonetcp/cyclone_tcp/http
    ../../../middleware/CycloneTCP/cyclone_tcp/http/: http_server.c http_server.h http_server_auth.c http_server_auth.h http_server_misc.c http_server_misc.h mime.c mime.h ssi.c ssi.h
  group cyclonetcp/cyclone_tcp/icecast
    ../../../middleware/CycloneTCP/cyclone_tcp/icecast/: icecast_client.c icecast_client.h
  group cyclonetcp/cyclone_tcp/ipv4
    ../../../middleware/CycloneTCP/cyclone_tcp/ipv4/: arp.c arp.h auto_ip.c auto_ip.h icmp.c icmp.h igmp.c igmp.h ipv4.c ipv4.h ipv4_frag.c ipv4_frag.h ipv4_routing.c ipv4_routing.h
  group cyclonetcp/cyclone_tcp/ipv6
    ../../../middleware/CycloneTCP/cyclone_tcp/ipv6/: icmpv6.c icmpv6.h ipv6.c ipv6.h ipv6_frag.c ipv6_frag.h ipv6_misc.c ipv6_misc.h ipv6_pmtu.c ipv6_pmtu.h ipv6_routing.c ipv6_routing.h mld.c mld.h ndp.c ndp.h ndp_cache.c ndp_cache.h ndp_misc.c ndp_misc.h ndp_router_adv.c ndp_router_adv.h slaac.c slaac.h
  group cyclonetcp/cyclone_tcp/mdns
    ../../../middleware/CycloneTCP/cyclone_tcp/mdns/: mdns_client.c mdns_client.h mdns_common.c mdns_common.h mdns_responder.c mdns_responder.h
  group cyclonetcp/cyclone_tcp/mibs
    ../../../middleware/CycloneTCP/cyclone_tcp/mibs/: if_mib_impl.c if_mib_impl.h if_mib_module.c if_mib_module.h ip_mib_impl.c ip_mib_impl.h ip_mib_module.c ip_mib_module.h mib2_impl.c mib2_impl.h mib2_module.c mib2_module.h mib_common.c mib_common.h snmp_community_mib_impl.c snmp_community_mib_impl.h snmp_community_mib_module.c snmp_community_mib_module.h snmp_framework_mib_impl.c snmp_framework_mib_impl.h snmp_framework_mib_module.c snmp_framework_mib_module.h snmp_mib_impl.c snmp_mib_impl.h snmp_mib_module.c snmp_mib_module.h snmp_usm_mib_impl.c snmp_usm_mib_impl.h snmp_usm_mib_module.c snmp_usm_mib_module.h snmp_vacm_mib_impl.c snmp_vacm_mib_impl.h snmp_vacm_mib_module.c snmp_vacm_mib_module.h tcp_mib_impl.c tcp_mib_impl.h tcp_mib_module.c tcp_mib_module.h udp_mib_impl.c udp_mib_impl.h udp_mib_module.c udp_mib_module.h
  group cyclonetcp/cyclone_tcp/mqtt
    ../../../middleware/CycloneTCP/cyclone_tcp/mqtt/: mqtt_client.c mqtt_client.h mqtt_client_misc.c mqtt_client_misc.h mqtt_client_packet.c mqtt_client_packet.h mqtt_client_transport.c mqtt_client_transport.h mqtt_common.h
  group cyclonetcp/cyclone_tcp/netbios
    ../../../middleware/CycloneTCP/cyclone_tcp/netbios/: nbns_client.c nbns_client.h nbns_common.c nbns_common.h nbns_responder.c nbns_responder.h
  group cyclonetcp/cyclone_tcp/ppp
    ../../../middleware/CycloneTCP/cyclone_tcp/ppp/: chap.c chap.h ipcp.c ipcp.h ipv6cp.c ipv6cp.h lcp.c lcp.h pap.c pap.h ppp.c ppp.h ppp_debug.c ppp_debug.h ppp_fsm.c ppp_fsm.h ppp_hdlc.c ppp_hdlc.h ppp_misc.c ppp_misc.h
  group cyclonetcp/cyclone_tcp/smtp
    ../../../middleware/CycloneTCP/cyclone_tcp/smtp/: smtp_client.c smtp_client.h
  group cyclonetcp/cyclone_tcp/snmp
    ../../../middleware/CycloneTCP/cyclone_tcp/snmp/: snmp_agent.c snmp_agent.h snmp_agent_dispatch.c snmp_agent_dispatch.h snmp_agent_inform.c snmp_agent_inform.h snmp_agent_message.c snmp_agent_message.h snmp_agent_misc.c snmp_agent_misc.h snmp_agent_object.c snmp_agent_object.h snmp_agent_pdu.c snmp_agent_pdu.h snmp_agent_trap.c snmp_agent_trap.h snmp_agent_usm.c snmp_agent_usm.h snmp_agent_vacm.c snmp_agent_vacm.h snmp_common.h
  group cyclonetcp/cyclone_tcp/sntp
    ../../../middleware/CycloneTCP/cyclone_tcp/sntp/: sntp_client.c sntp_client.h
  group cyclonetcp/cyclone_tcp/std_services
    ../../../middleware/CycloneTCP/cyclone_tcp/std_services/: chargen.c chargen.h daytime.c daytime.h discard.c discard.h echo.c echo.h
  group cyclonetcp/cyclone_tcp/tftp
    ../../../middleware/CycloneTCP/cyclone_tcp/tftp/: tftp_client.c tftp_client.h tftp_client_misc.c tftp_client_misc.h tftp_common.h tftp_server.c tftp_server.h tftp_server_misc.c tftp_server_misc.h
  group cyclonetcp/cyclone_tcp/web_socket
    ../../../middleware/CycloneTCP/cyclone_tcp/web_socket/: web_socket.c web_socket.h web_socket_auth.c web_socket_auth.h web_socket_frame.c web_socket_frame.h web_socket_misc.c web_socket_misc.h web_socket_transport.c web_socket_transport.h
  group doc
    ../: readme.txt
  group drivers
    ../../../devices/MCIMX6G3/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_ecspi.c fsl_ecspi.h fsl_ecspi_freertos.c fsl_ecspi_freertos.h fsl_enet.c fsl_enet.h fsl_epit.c fsl_epit.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_uart.c fsl_uart.h fsl_usdhc.c fsl_usdhc.h
  group drivers/freertos
    ../../../devices/MCIMX6G3/drivers/: fsl_uart_freertos.c fsl_uart_freertos.h
  group fatfs
    ../../../middleware/fatfs_0.12c/src/: diskio.c diskio.h ff.c ff.h integer.h
  group fatfs/fsl_sd_disk
    ../../../middleware/fatfs_0.12c/src/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group freertos
    ../../../rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../rtos/freertos_9.0.0/Source/portable/low_power_tickless/: fsl_tickless_epit.c
    ../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9/: port.c portASM.h portASM.s portmacro.h
  group sdmmc
    ../../../middleware/sdmmc_2.1.2/src/: fsl_mmc.c fsl_sd.c fsl_sdio.c fsl_sdmmc.c fsl_sdspi.c
  group sdmmc/port
    ../../../middleware/sdmmc_2.1.2/port/usdhc/freertos/: event.c fsl_host.c
  group source
    ../: FreeRTOSConfig.h main.c res.c sd_init.c sd_init.h
  group startup
    ../../../devices/MCIMX6G3/: MCIMX6G3.h system_MCIMX6G3.c system_MCIMX6G3.h
    ../../../devices/MCIMX6G3/iar/: startup_MCIMX6G3.s
