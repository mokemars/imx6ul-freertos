# IAR project canopen_canfestival.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 51
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6G3CVM05; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS; EVK_MCIMX6UL; CYCLONE_OS_DEBUG
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9; ../../../rtos/freertos_9.0.0/Source/include; ../../../CORTEXA/Include; ../../../devices; ..; ..\..\..\middleware\canfestival\include; ..\..\..\middleware\canfestival\include\imx6x; ..\can_master; ..\can_slave; ../../..; ../../../rtos/freertos_9.0.0/Source; ../../../devices/MCIMX6G3/drivers; ../../../platform/utilities/debug_console; ../../../platform/utilities/debug_console/io; ../../../platform/utilities/debug_console/str; ../../../devices/MCIMX6G3/utilities; ../../../devices/MCIMX6G3; ..\..\..\middleware\CycloneTCP\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../..
  OBJCOPY.OOCOutputFile: canopen_canfestival.bin
  ILINK.IlinkOutputFile: canopen_canfestival_ca.out
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_ram.icf
  ILINK.IlinkAdditionalLibs: $TOOLKIT_DIR$\..\..\..\..\nxp\DISCOVERY_MCIM6UL\discovery\discovery_core\lib\ddr_debug\discovery_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MCIMX6G3CVM05; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS; EVK_MCIMX6UL; CYCLONE_OS_DEBUG; GPL_LICENSE_TERMS_ACCEPTED
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\discovery_core\lib\debug\discovery_core.a
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\..\discovery_core\lib\ddr_release\discovery_core.a
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\discovery_core\lib\release\discovery_core.a
  group board
    ../: board.c board.h clock_config.c clock_config.h clock_config_ocram.c pin_mux.c pin_mux.h
  group canfestival/src
    ../../../middleware/canfestival/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group canmaster
    ../can_master/: MasterObjDict.c MasterObjDict.h MasterObjDictConfig.c MasterObjDictConfig.h
  group canslave
    ../can_slave/: SlaveCanOpen.c SlaveCanOpen.h SlaveObjDict.c SlaveObjDict.h SlaveObjDictConfig.c SlaveObjDictConfig.h
  group common
    ../../../middleware/CycloneTCP/common/: debug.c debug.h os_port_freertos.c os_port_freertos.h
  group doc
    ../: readme.txt
  group drivers
    ../../../devices/MCIMX6G3/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_epit.c fsl_epit.h fsl_flexcan.c fsl_flexcan.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_uart.c fsl_uart.h
  group freertos
    ../../../rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9/: port.c portASM.h portASM.s portmacro.h
  group source
    ../: FreeRTOSConfig.h main.c
  group startup
    ../../../devices/MCIMX6G3/iar/: startup_MCIMX6G3.s
    ../../../devices/MCIMX6G3/: system_MCIMX6G3.c system_MCIMX6G3.h
